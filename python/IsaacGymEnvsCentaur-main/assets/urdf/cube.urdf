Commit message: Update 1.0.1

File: python/IsaacGymEnvsCentaur-main/assets/urdf/cube.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- removed link object
- added link base_link, mass 1.0; collision box size=0.1 0.1 0.1; visual box size=0.1 0.1 0.1
